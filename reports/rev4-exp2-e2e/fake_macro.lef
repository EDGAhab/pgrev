VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO FAKE_SRAM
  CLASS BLOCK ;
  FOREIGN FAKE_SRAM 0.0 0.0 ;
  ORIGIN 0.0 0.0 ;
  SIZE 50.0 BY 50.0 ;
  OBS
    LAYER met4 ;
      RECT 0.0 0.0 50.0 50.0 ;
    LAYER met5 ;
      RECT 0.0 0.0 50.0 50.0 ;
  END
END FAKE_SRAM

END LIBRARY
